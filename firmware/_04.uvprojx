# Keil uVision project _04.uvprojx, settings and files
target _04 OS (6220000::V6.22::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: _04
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT = 1,__FPU_USED=1
  c misc: -fomit-frame-pointer -ffunction-sections -fdata-sections
  c include: .\_01_App;.\_02_Core;.\_04_FWLib\STM32F40x_FWLib\inc;.\_05_Os;.\_06_System;.\_03_Drive;..\02_OS;.\_08_USB\STM32_USB_Device_Library\Core\inc;.\_08_USB\STM32_USB_HOST_Library\Core\inc;.\_08_USB\STM32_USB_OTG_Driver\inc;.\_08_USB\USB_APP;.\_08_USB\STM32_USB_HOST_Library\Class\HID\inc;.\_07_TFT_LCD
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\AC6_scatter.sct
  group App
    ./_01_App/: App_LED.c App_Touch.c User.c app_fft.c app_sweep.c app_measure.c
  group User
    ./: main.c
    ./_05_Os/: User_header.h
  group OS
    ./_05_Os/: Os_cpu.c Os_UI.c Os_malloc.c core.asm
  group SYSTEM
    ./_06_System/: sys.c delay.c usart.c
  group Drive
    ./_03_Drive/: Drive_GPIO.c Drive_PS2.c Drive_ADS1256.c Drive_AD9959.c Drive_ADC.c User_ADC.c Drive_DAC.c Drive_Touch.c Drive_AD637.c Drive_Comparator.c Drive_AD9240.c Drive_Dwin.c
  group TFT
    ./_07_TFT_LCD/: Character.c fonts.c fontupd.c spi.c text.c TFT_LCD.c W25Q64.c
  group FWLIB
    ./_04_FWLib/STM32F40x_FWLib/src/: stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_can.c
  group Core
    ./_02_Core/: stm32f4xx_it.c system_stm32f4xx.c arm_math.h startup_stm32f40_41xxx.s arm_cortexM4lf_math.lib
software components: CMSIS:CORE 6.2.0
